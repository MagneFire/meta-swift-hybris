SRCREV_swift = "8883e9aca7de870a4a93b31e82cfc600c51cef5d"


#SRC_URI_append_swift = " file://0002-egl-Adapt-wayland-egl-to-upstream-and-use-upstream-w.patch;striplevel=2 
#                            file://0003-hybris-gles-Add-GLESv3-headers.patch;striplevel=2 "
